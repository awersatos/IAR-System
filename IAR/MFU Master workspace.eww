<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Brelok_MFU v 1.00\Brelok_MFU v 1.00.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MFU v 1.00\MFU v1.00.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TEST\STM32-DISCOVERY\TEST_AES\TEST_AES.ewp</path>
  </project>
  <batchBuild/>
</workspace>



<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Brelok_MFU v 1.00.ewp</path>
  </project>
  <batchBuild/>
</workspace>


